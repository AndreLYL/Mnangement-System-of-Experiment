# Keil uVision project as608.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\LCD;..\USMART;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\NRF24L01;..\HARDWARE\PS2;..\HARDWARE\STMFLASH;..\MALLOC;..\HARDWARE\SD;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\SIM900A;..\HARDWARE\USART2;..\HARDWARE\AS608;..\RFID-RC522;..\MY_GUI;..\PICTURE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ott2001a.c touch.c ft5206.c gt9147.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/AS608/: as608.c as608_add.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DS18B20/: ds18b20.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group README
    ../: README.TXT Note.txt
  group MY_GUI
    ../MY_GUI/: MY_GUI.c
  group RC_522
    ../RFID-RC522/: rc522.c rc522_add.c
  group Picture
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
